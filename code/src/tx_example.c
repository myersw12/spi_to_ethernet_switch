#include <stdio.h>
#include <errno.h>
#include <wiringPiSPI.h>
#include <unistd.h>
#include <w3150.h>
#include <stdlib.h>

// Simple transmit example using the W3150.  The icmp repsonse
// frame below is send every second.

uint8_t icmp_response[] = {0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xde, 0xad, 0xbe, 0xef, 0xba, 0x5e, 0x08, 0x00, 0x45,
    0x00, 0x00, 0x54, 0x00, 0x06, 0x40, 0x00, 0x80, 0x01,
    0x13, 0xac, 0xc0, 0xa8, 0x32, 0xdd, 0xc0, 0xa8, 0x32,
    0xc9, 0x00, 0x00, 0x16, 0x86, 0x16, 0xd7, 0x00, 0x06,
    0x72, 0xcc, 0xfb, 0x58, 0x00, 0x00, 0x00, 0x00, 0xa3,
    0xa4, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x11,
    0x12, 0x13, 0x14, 0x15, 0x16, 0x17, 0x18, 0x19, 0x1a,
    0x1b, 0x1c, 0x1d, 0x1e, 0x1f, 0x20, 0x21, 0x22, 0x23,
    0x24, 0x25, 0x26, 0x27, 0x28, 0x29, 0x2a, 0x2b, 0x2c,
    0x2d, 0x2e, 0x2f, 0x30, 0x31, 0x32, 0x33, 0x34, 0x35,
    0x36, 0x37};

int main(void) {

    uint8_t mac_address[6] = {0xde,0xad,0xbe,0xef,0xba,0x5e};
    uint8_t local_host[4]  = {192,168,50,221};
    uint8_t gateway[4]     = {192,168,50,1};
    uint8_t subnet[4]     =  {255,255,255,0};

    printf("--------Transmit Example--------\n");
    w3150_init_networking(mac_address,local_host,gateway,subnet);

    if (w3150_init_macraw() != 1){
        printf("macraw init failed\n");
        exit(0);
    }

    while(1){
        if (w3150_macraw_write(icmp_response, 98) != 1){
            printf("macraw write failed\n");
            exit(0);
        }

        printf("Finished Write\n");

        sleep(1);
    }

    return 0;
}
